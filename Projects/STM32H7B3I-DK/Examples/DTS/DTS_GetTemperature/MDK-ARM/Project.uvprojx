# Keil uVision project Project.uvprojx, settings and files
target STM32H7B3I_DISCO_DTS_GetTemperature (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.2
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_DISCO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7B3xxQ,USE_STM32H7B3I_DISCOVERY
  c include: ../Inc;../../../../../../Drivers/BSP/STM32H7B3I-DK;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/Basic_GUI;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Drivers/BSP/STM32H7B3I-DK
    ../../../../../../Drivers/BSP/STM32H7B3I-DK/: stm32h7b3i_discovery.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dts.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
software components: CMSIS:CORE 4.3.0
