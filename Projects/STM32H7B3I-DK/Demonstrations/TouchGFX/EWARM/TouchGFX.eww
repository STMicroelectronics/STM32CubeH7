<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TouchGFX.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>everything</name>
            <member>
                <project>TouchGFX</project>
                <configuration>TouchGFX-STM32H7B3I-DK</configuration>
            </member>
            <member>
                <project>TouchGFX</project>
                <configuration>TouchGFX-STM32H7B3I-DK_OoB</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
