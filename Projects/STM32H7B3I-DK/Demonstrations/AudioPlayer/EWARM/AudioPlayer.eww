<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\AudioPlayer.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>everything</name>
            <member>
                <project>AudioPlayer</project>
                <configuration>AudioPlayer-STM32H7B3I-DK</configuration>
            </member>
            <member>
                <project>AudioPlayer</project>
                <configuration>AudioPlayer-STM32H7B3I-DK_OOB</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
