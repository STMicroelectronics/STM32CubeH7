<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MenuLauncher.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>everything</name>
            <member>
                <project>MenuLauncher</project>
                <configuration>MenuLauncher-STM32H7B3I-DK</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
