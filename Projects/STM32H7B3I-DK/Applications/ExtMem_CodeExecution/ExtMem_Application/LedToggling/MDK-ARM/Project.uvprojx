# Keil uVision project Project.uvprojx, settings and files
target BootROM_ExternalSDRAM_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0ABIxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0xD0000000U,USE_HAL_DRIVER,STM32H7B0xxQ
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Utilities/Fonts;../../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0xd0000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
  group Example/MDK-ARM
    ./: startup_stm32h7b0xxq.s
  group Example/User
    ../Src/: main.c stm32h7xx_it.c
target XIP_OSPI_ExternalSDRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0ABIxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: as above
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,USE_HAL_DRIVER,STM32H7B0xxQ
  c include: ../Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32H750B-Discovery;../../../../../../../Drivers/BSP/Components/Common;../../../../../../../Utilities/Fonts;../../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x4000000
  memory RVCT9: RAM 0xd0000000 size 0x800000
  memory RVCT10: RAM 0x0 size 0x1000
target XIP_OSPI_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0ABIxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: as above
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,USE_HAL_DRIVER,STM32H7B0xxQ
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x4000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 5.2.0
