# IAR project Project.ewp, settings and files
configuration STM32H7B3I_DISCO_DMA2D_MemoryToMemory (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7B3LI-Q ST STM32H7B3LI-Q
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H7B3xxQ; USE_STM32H7B3I_DISCOVERY; USE_FULL_LL_DRIVER; HSE_VALUE=24000000U
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32H7B3I_DISCO.out
  ILINK.IlinkIcfFile: stm32h7b3xxq_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_LL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32h7b3xxq.s
  group Example/User
    ../Src/: main.c stm32h7xx_it.c
