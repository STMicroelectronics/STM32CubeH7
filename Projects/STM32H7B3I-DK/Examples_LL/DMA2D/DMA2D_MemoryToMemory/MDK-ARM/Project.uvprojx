# Keil uVision project Project.uvprojx, settings and files
target STM32H7B3I_DISCO_DMA2D_MemoryToMemory (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x24000000-0x240FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_DISCO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32H7B3xxQ,USE_STM32H7B3I_DISCOVERY,USE_FULL_LL_DRIVER,HSE_VALUE=24000000U
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x24000000 size 0x100000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_LL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Example/User
    ../Src/: main.c stm32h7xx_it.c
software components: CMSIS:CORE 4.3.0
