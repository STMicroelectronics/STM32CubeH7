# Keil uVision project Project.uvprojx, settings and files
target STM32H745I_DISCO_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.5
  cpu: IROM(0x08100000-0x81FFFFF) IRAM(0x10000000-0x10047FFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32H745I_DISCO_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER, STM32H745xx,CORE_CM4
  c include: ../CM4/Inc;../Common/Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../Drivers/STM32H7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_LL_Driver
    ../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_crc.c stm32h7xx_ll_dac.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32h745xx.s
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_it.c
target STM32H745I_DISCO_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.5
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H745I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER, STM32H745xx,CORE_CM7
  c include: ../CM7/Inc;../Common/Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../Drivers/STM32H7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
software components: CMSIS:CORE 4.3.0
