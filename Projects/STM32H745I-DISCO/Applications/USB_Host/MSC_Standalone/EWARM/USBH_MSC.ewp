# IAR project USBH_MSC.ewp, settings and files
configuration STM32H745I-DISCO_USBH-FS (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745XI_CM7 ST STM32H745XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H745xx; USE_HAL_DRIVER; USE_USB_FS; CORE_CM7
  ICCARM.CCIncludePath2: ..\CM7\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H745I-DISCO; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\..\Utilities\Basic_GUI; ..\..\..\..\..\..\Utilities\Lcd_Trace
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_MSC.hex
  ILINK.IlinkOutputFile: STM32H745I-DISCO_USBH-FS.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H745I-DISCO_CM4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745XI_CM4 ST STM32H745XI_CM4
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32H747xx; USE_HAL_DRIVER; CORE_CM4
  ICCARM.CCIncludePath2: ..\CM4\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc
  OBJCOPY.OOCOutputFile: USBH_CM4.hex
  ILINK.IlinkOutputFile: STM32H745I_DISCO_CM4.out
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  group Application/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c
  group Application/CM7
    ../CM7/Src/: explorer.c file_operations.c main.c menu.c stm32h7xx_it.c usbh_conf.c usbh_diskio.c
  group Application/EWARM
    ./: startup_stm32h745xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
  group Drivers/BSP/STM32H745I_DISCO
    ../../../../../../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery_bus.c stm32h745i_discovery_lcd.c stm32h745i_discovery_sdram.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c
  group Middlewares/FatFS
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Utilities
    ../../../../../../Utilities/Basic_GUI/: basic_gui.c
    ../../../../../../Utilities/Lcd_Trace/: lcd_trace.c
