# Keil uVision project Project.uvprojx, settings and files
target STM32H745I_DISCO_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.1
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x24000000-0x2407FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H745I_DISCO_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H745xx, USE_STM32H745I_DISCO,CORE_CM7
  c include: ../Common/Inc;../CM7/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H745I-DISCO;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../../Utilities/Basic_GUI;..\Common\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
    ../../../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
  group Drivers/BSP/STM32H745I_DISCO
    ../../../../../../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery_lcd.c stm32h745i_discovery_sdram.c stm32h745i_discovery_bus.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_exti.c
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32h745xx.s
  group Utilities
    ../../../../../../Utilities/Basic_GUI/: basic_gui.c
target STM32H745I_DISCO_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H745XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32H745I_DISCO_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H745xx,USE_STM32H745I_DISCO,CORE_CM4
  c include: ../Common/Inc;../CM4/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H745I-DISCO;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 4.3.0
