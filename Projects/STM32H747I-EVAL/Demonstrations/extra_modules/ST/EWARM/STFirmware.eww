<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STFirmware.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Build all</name>
            <member>
                <project>STFirmware</project>
                <configuration>STM32H747I_DISCO_CM4</configuration>
            </member>
            <member>
                <project>STFirmware</project>
                <configuration>STM32H747I_DISCO_CM7</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
