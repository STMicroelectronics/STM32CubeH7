# Keil uVision project STFirmware.uvprojx, settings and files
target STFirmware-STM32H747I-EVAL_OoB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IROM(0x08100000-0x813FFFF) IRAM(0x10000000-0x1003FFFF) CLOCK(12000000) FPU2 CPUTYPE("Cortex-M4")
  output: STFirmware-STM32H747I-EVAL_OoB_V1.0.0 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H747xx,USE_STM32H747I_EVAL,CORE_CM4
  c misc: --C99
  c include: ../Core/Common/Inc;../Core/CM4/Inc;../../STIPC/Core/Common/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Fonts;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Core/CM4/Inc;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ../Core/CM4/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x40000
  scatter file: STFirmware-STM32H747I-EVAL_OoB\Exe\STFirmware-STM32H747I-EVAL_OoB_V1.0.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
  group Application/User/CM4
    ../Core/CM4/Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/Common
    ../Core/Common/Src/: bsp.c stm32h7xx_hal_msp.c
    ../../STIPC/Core/Common/Src/: cm_ipc.c
  group Application/User/Firmwares
    ../Core/CM4/Src/: fw_fractal.c fw_motion.c motion_detection.c
  group Drivers/BSP/STM32H747I_EVAL
    ../../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_bus.c stm32h747i_eval_io.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_exti.c
  group Middlewares/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
software components: CMSIS:CORE 5.1.1
