# Keil uVision project Project.uvprojx, settings and files
target STM32H747I_EVAL_CM7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H757XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.5
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H747I_EVAL_CM7 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H757xx, USE_STM32H747I_EVAL,USE_IOEXPANDER,CORE_CM7
  c include: ../Common/Inc;../CM7/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/Basic_GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32H747I_EVAL
    ../../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_io.c stm32h747i_eval_bus.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Example/User/CM4
    ../CM4/Src/: main.c stm32h7xx_it.c
  group Example/User/CM7
    ../CM7/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Example/MDK-ARM
    ./: startup_stm32h757xx.s
target STM32H747I_EVAL_CM4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H757XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.5
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32H747I_EVAL_CM4 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H757xx, USE_STM32H747I_EVAL,USE_IOEXPANDER,CORE_CM4
  c include: ../Common/Inc;../CM4/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/Basic_GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  memory RVCT10: RAM 0x24000000 size 0x80000
software components: CMSIS:CORE 5.1.1
