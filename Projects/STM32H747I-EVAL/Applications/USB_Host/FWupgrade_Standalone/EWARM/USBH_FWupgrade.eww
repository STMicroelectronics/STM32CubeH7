<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBH_FWupgrade.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBH_FWupgrade</project>
        <configuration>STM32H747I_EVAL_USBH-FS</configuration>
      </member>
      <member>
        <project>USBH_FWupgrade</project>
        <configuration>STM32H747I_EVAL_USBH-HS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


