<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\USBD_DualCore.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>USBD_DualCore</project>
        <configuration>STM32756G-EVAL_USBD-FS</configuration>
      </member>
      <member>
        <project>USBD_DualCore</project>
        <configuration>STM32756G-EVAL_USBD-HS</configuration>
      </member>
      <member>
        <project>USBD_DualCore</project>
        <configuration>STM32756G-EVAL_USBD-HS-IN-FS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


