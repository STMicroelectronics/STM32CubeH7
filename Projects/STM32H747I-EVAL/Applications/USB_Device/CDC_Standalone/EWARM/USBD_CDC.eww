<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USBD_CDC.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>build All</name>
            <member>
                <project>USBD_CDC</project>
                <configuration>STM32H747I-EVAL_USBD-FS</configuration>
            </member>
            <member>
                <project>USBD_CDC</project>
                <configuration>STM32H747I-EVAL_USBD-HS</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
