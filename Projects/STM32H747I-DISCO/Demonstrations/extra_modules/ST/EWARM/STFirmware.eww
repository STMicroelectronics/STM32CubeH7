<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STFirmware.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Build all</name>
            <member>
                <project>STFirmware</project>
                <configuration>STFirmware-STM32H747I-DISCO_OoB</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
