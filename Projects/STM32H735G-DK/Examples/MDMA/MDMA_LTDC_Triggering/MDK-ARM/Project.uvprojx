# Keil uVision project Project.uvprojx, settings and files
target STM32H735G-DK_MDMA_LTDC_Triggering (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H735IGKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.2
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x24000000-0x2404FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H735G-DK +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H735xx
  c include: ../Inc;../../../../../../Drivers/BSP/STM32H735G-DK;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x24000000 size 0x50000
  memory RVCT10: RAM 0x0 size 0x10000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../../Drivers/BSP/Components/s70kl1281/: s70kl1281.c
  group Drivers/BSP/STM32H735G-DK
    ../../../../../../Drivers/BSP/STM32H735G-DK/: stm32h735g_discovery.c stm32h735g_discovery_bus.c stm32h735g_discovery_lcd.c stm32h735g_discovery_ospi.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Example/MDK-ARM
    ./: startup_stm32h735xx.s
  group Example/User
    ../Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
