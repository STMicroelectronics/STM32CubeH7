# Keil uVision project Project.uvprojx, settings and files
target STM32H735G-DK-OTFDEC_ExecutingCryptedInstruction (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H735IGKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.2
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H735G-DK-OTFDEC_ExecutingCryptedInstruction +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H735xx
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H735G-DK;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/lcd;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32H735G-DK
    ../../../../../../Drivers/BSP/STM32H735G-DK/: stm32h735g_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_usb.c
  group Example/MDK-ARM
    ./: startup_stm32h735xx.s
  group Example/User
    ../Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
software components: CMSIS:CORE 4.3.0
