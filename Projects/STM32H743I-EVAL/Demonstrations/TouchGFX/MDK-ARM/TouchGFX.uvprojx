# Keil uVision project TouchGFX.uvprojx, settings and files
target TouchGFX-STM32H743I-EVAL_OoB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x08170000-0x81FFFFF) IRAM(0x24000000-0x2407FFFF) IRAM2(0x00000000-0x3FFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: TouchGFX-STM32H743I-EVAL_OoB_V1.1.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_BPP=16,ST,STM32H743xx,USE_HAL_DRIVER,USE_IOEXPANDER,LCD_CLK_TUNING
  c misc: --diag_suppress 1300
  c include: ../Config;../Core/Inc;../Gui/generated/images/include;../Gui/generated/fonts/include;../Gui/generated/texts/include;../Gui/gui/include;../Gui/gui/include/gui/audio_player_screen;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../Utilities/JPEG;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../Drivers/CMSIS/Include;../Gui/target;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../Drivers/BSP/Components/Common
  asm include: ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1;../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8170000 size 0x90000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\TouchGFX-STM32H743I-EVAL_OoB.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Gui/gui/include/gui/audio_player_screen/: audio_player_app.c
    ../Core/Src/: hwjpeg_decode.c main.cpp mfx.c rtc_app.c sd_diskio_dma.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage_app.c system_stm32h7xx_singlecore.c
  group Application/User/TouchGFX/fonts
    ../Gui/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Asap_Bold_otf_20_4bpp_0.cpp Font_Asap_Regular_16_4bpp_0.cpp Font_Asap_Regular_18_4bpp_0.cpp Font_Asap_Regular_20_4bpp_0.cpp Font_NotoSans_Regular_22_4bpp_0.cpp Font_PatuaOne_Regular_16_4bpp_0.cpp Font_PatuaOne_Regular_30_4bpp_0.cpp Font_Roboto_Bold_22_4bpp_0.cpp Font_Roboto_Medium_30_4bpp_0.cpp Font_RobotoCondensed_Bold_18_4bpp_0.cpp Font_RobotoCondensed_Bold_18_4bpp_4.cpp Font_RobotoCondensed_Bold_20_4bpp_0.cpp Font_RobotoCondensed_Bold_22_4bpp_0.cpp Font_RobotoCondensed_Bold_22_4bpp_4.cpp Font_RobotoCondensed_Bold_30_4bpp_0.cpp Font_RobotoCondensed_Bold_32_4bpp_0.cpp Font_RobotoCondensed_Bold_42_4bpp_0.cpp Font_RobotoCondensed_Bold_48_4bpp_0.cpp Font_RobotoCondensed_Bold_60_4bpp_0.cpp Font_RobotoCondensed_Bold_90_4bpp_0.cpp Font_RobotoCondensed_Regular_110_4bpp_0.cpp Font_RobotoCondensed_Regular_13_4bpp_0.cpp Font_RobotoCondensed_Regular_18_4bpp_0.cpp Font_RobotoCondensed_Regular_18_4bpp_4.cpp Font_RobotoCondensed_Regular_20_4bpp_0.cpp Font_RobotoCondensed_Regular_20_4bpp_4.cpp Font_RobotoCondensed_Regular_22_4bpp_0.cpp Font_RobotoCondensed_Regular_38_4bpp_0.cpp Font_RobotoCondensed_Regular_40_4bpp_0.cpp Font_RobotoCondensed_Regular_54_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Asap_Bold_otf_20_4bpp.cpp Kerning_Asap_Regular_13_4bpp.cpp Kerning_Asap_Regular_16_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Kerning_Asap_Regular_20_4bpp.cpp Kerning_NotoSans_Regular_22_4bpp.cpp Kerning_PatuaOne_Regular_16_4bpp.cpp Kerning_PatuaOne_Regular_30_4bpp.cpp Kerning_Roboto_Bold_22_4bpp.cpp Kerning_Roboto_Medium_30_4bpp.cpp Kerning_RobotoCondensed_Bold_18_4bpp.cpp Kerning_RobotoCondensed_Bold_20_4bpp.cpp Kerning_RobotoCondensed_Bold_22_4bpp.cpp Kerning_RobotoCondensed_Bold_30_4bpp.cpp Kerning_RobotoCondensed_Bold_32_4bpp.cpp Kerning_RobotoCondensed_Bold_42_4bpp.cpp Kerning_RobotoCondensed_Bold_48_4bpp.cpp Kerning_RobotoCondensed_Bold_60_4bpp.cpp Kerning_RobotoCondensed_Bold_90_4bpp.cpp Kerning_RobotoCondensed_Regular_110_4bpp.cpp Kerning_RobotoCondensed_Regular_13_4bpp.cpp Kerning_RobotoCondensed_Regular_18_4bpp.cpp Kerning_RobotoCondensed_Regular_20_4bpp.cpp Kerning_RobotoCondensed_Regular_22_4bpp.cpp Kerning_RobotoCondensed_Regular_38_4bpp.cpp Kerning_RobotoCondensed_Regular_40_4bpp.cpp Kerning_RobotoCondensed_Regular_54_4bpp.cpp Table_Asap_Bold_otf_20_4bpp.cpp Table_Asap_Regular_13_4bpp.cpp Table_Asap_Regular_16_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp Table_Asap_Regular_20_4bpp.cpp Table_NotoSans_Regular_22_4bpp.cpp Table_PatuaOne_Regular_16_4bpp.cpp Table_PatuaOne_Regular_30_4bpp.cpp Table_Roboto_Bold_22_4bpp.cpp Table_Roboto_Medium_30_4bpp.cpp Table_RobotoCondensed_Bold_18_4bpp.cpp Table_RobotoCondensed_Bold_20_4bpp.cpp Table_RobotoCondensed_Bold_22_4bpp.cpp Table_RobotoCondensed_Bold_30_4bpp.cpp Table_RobotoCondensed_Bold_32_4bpp.cpp Table_RobotoCondensed_Bold_42_4bpp.cpp Table_RobotoCondensed_Bold_48_4bpp.cpp Table_RobotoCondensed_Bold_60_4bpp.cpp Table_RobotoCondensed_Bold_90_4bpp.cpp Table_RobotoCondensed_Regular_110_4bpp.cpp Table_RobotoCondensed_Regular_13_4bpp.cpp Table_RobotoCondensed_Regular_18_4bpp.cpp Table_RobotoCondensed_Regular_20_4bpp.cpp Table_RobotoCondensed_Regular_22_4bpp.cpp Table_RobotoCondensed_Regular_38_4bpp.cpp Table_RobotoCondensed_Regular_40_4bpp.cpp Table_RobotoCondensed_Regular_54_4bpp.cpp
  group Application/User/TouchGFX/gui
    ../Gui/gui/src/settings_screen/: AnalogClock.cpp AnalogClockWithSetTimeFunctionality.cpp ClockSelectorContainer.cpp DatePicker.cpp DateSelectorContainer.cpp SettingsPresenter.cpp SettingsView.cpp TimeSettingContainer.cpp WheelSelector.cpp
    ../Gui/gui/src/common/: AnimationTextureMapper.cpp BottomBar.cpp Carousel.cpp CollapsibleMenu.cpp DemoPresenter.cpp DotIndicator.cpp FrontendApplication.cpp LoginWidget.cpp SwipeContainer.cpp TiledImage.cpp TopBar.cpp ZoomAnimationBox.cpp
    ../Gui/gui/src/gameKnight_screen/: Arrow.cpp GameKnightPresenter.cpp GameKnightView.cpp GameStatusPopup.cpp Head.cpp Knight.cpp TiledImageBugFixed.cpp Zombie.cpp
    ../Gui/gui/src/audio_player_screen/: AudioBottomBar.cpp AudioFolderWidget.cpp AudioPlayer.cpp AudioPlayerPlaylist.cpp AudioPlayerPresenter.cpp AudioPlayerView.cpp BMPFileLoader.cpp CoverWidget.cpp Equalizer.cpp visualization.c VisualizationWidget.cpp
    ../Gui/gui/src/bump_map_screen/: BumpMapImage.cpp BumpMapPresenter.cpp BumpMapView.cpp
    ../Gui/gui/src/controls_screen/: CircularValueIndicator.cpp ControlsPresenter.cpp ControlsView.cpp
    ../Gui/gui/src/video_player_screen/: FatFSFileInput.cpp FolderWidget.cpp JPEGFileInput.cpp MJPEGReader.cpp PlaylistWidget.cpp StdFileInput.cpp VideoBottomBar.cpp VideoPlayerPresenter.cpp VideoPlayerView.cpp VideoProgressBar.cpp
    ../Gui/gui/src/game2048_screen/: Game2048Presenter.cpp Game2048View.cpp GameBoard.cpp
    ../Gui/gui/src/home_automation_screen/: Graph.cpp GraphLine.cpp HomeAutomationPresenter.cpp HomeAutomationView.cpp PainterRGB565TiledBitmap.cpp PainterRGB888TiledBitmap.cpp RoomControl.cpp RoomControlAdjustable.cpp RoomControlToggle.cpp RoomControlWheel.cpp StatisticsContainer.cpp
    ../Gui/gui/src/main_menu_screen/: MainMenuAnimatingButtonsView.cpp MainMenuCarouselView.cpp MainMenuPresenter.cpp MainMenuView.cpp
    ../Gui/gui/src/model/: Model.cpp
    ../Gui/generated/images/src/Audio/: speaker_down_notPressed.cpp speaker_down_Pressed.cpp speaker_mute.cpp speaker_notmute.cpp speaker_up_Pressed.cpp
  group Application/User/TouchGFX/images
    ../Gui/generated/images/src/AudioPlayer/: album_circle_256.cpp album_circle_shadow.cpp audio_default_background.cpp back_icon_pressed.cpp cover_no_media.cpp cover_small.cpp cover_tiny.cpp cover_unknown_artist.cpp equalizer_background.cpp equalizer_bar_fill.cpp equalizer_bar_knop.cpp equalizer_bar_unfill.cpp equalizer_db_value.cpp equalizer_icon.cpp equalizer_icon_pressed.cpp folder_icon.cpp folder_list_icon.cpp loudness_knop.cpp next_button.cpp next_button_pressed.cpp pause_button.cpp play_button.cpp player-_list_process_circle_.cpp playlist_cover_mask.cpp playlist_cover_overlay.cpp playlist_cover_shadow.cpp playlist_icon.cpp playlist_icon_pressed.cpp playlist_remove.cpp playlist_remove_pressed.cpp playlist_underline.cpp playlist_underline_playing.cpp previous_button.cpp previous_button_pressed.cpp process_circle.cpp process_circle_knop.cpp song_list_icon.cpp volume_bar.cpp volume_bar_fill.cpp volume_icon.cpp volume_knob.cpp
    ../Gui/generated/images/src/AnimatingButtonsMenu/: Animating_buttons_background.cpp Animating_buttons_full_table_shadow_bottom.cpp Animating_buttons_full_table_shadow_left.cpp Animating_buttons_full_table_shadow_right.cpp animating_buttons_menu_icons_2048_tiny.cpp animating_buttons_menu_icons_audio_player_tiny.cpp animating_buttons_menu_icons_bump_map_tiny.cpp animating_buttons_menu_icons_controls_tiny.cpp animating_buttons_menu_icons_home_automation_tiny.cpp animating_buttons_menu_icons_knight_tiny.cpp animating_buttons_menu_icons_settings_tiny.cpp animating_buttons_menu_icons_video_player_tiny.cpp Animating_buttons_table_element_shadow.cpp
    ../Gui/generated/images/src/GameKnight/: arrow_image.cpp attack_button.cpp attack_button_pressed.cpp background_layer_00.cpp background_layer_01.cpp background_layer_02.cpp chrom_art_off.cpp chrom_art_on.cpp Dead_01.cpp Dead_02.cpp Dead_03.cpp Dead_04.cpp Dead_05.cpp Dead_06.cpp Dead_07.cpp Dead_08.cpp Dead_09.cpp dead_bush.cpp head_00.cpp head_01.cpp head_02.cpp head_03.cpp head_04.cpp head_05.cpp head_06.cpp head_07.cpp head_08.cpp head_09.cpp Jump_00.cpp Jump_01.cpp Jump_02.cpp Jump_03.cpp Jump_04.cpp Jump_05.cpp Jump_06.cpp Jump_07.cpp Jump_08.cpp Jump_09.cpp jump_button.cpp jump_button_pressed.cpp JumpAttack_00.cpp JumpAttack_01.cpp JumpAttack_02.cpp JumpAttack_03.cpp JumpAttack_04.cpp JumpAttack_05.cpp JumpAttack_06.cpp JumpAttack_07.cpp JumpAttack_08.cpp JumpAttack_09.cpp knight_back_button.cpp knight_back_button_pressed.cpp knight_menu_background.cpp knight_play_button.cpp knight_play_button_pressed.cpp knight_progress_bar.cpp knight_slider_background.cpp life_head.cpp life_head_off.cpp popup_progress_bar.cpp popup_progress_bar_head_icon.cpp popup_progress_bar_lost.cpp popup_progress_bar_victory_icon.cpp popup_progress_bar_won.cpp ribbon_game_over.cpp ribbon_title.cpp ribbon_victory.cpp Run_00.cpp Run_01.cpp Run_02.cpp Run_03.cpp Run_04.cpp Run_05.cpp Run_06.cpp Run_07.cpp Run_08.cpp Run_09.cpp skeleton.cpp Tile.cpp tombstone.cpp touchgfx_logo.cpp zombie_attack_00.cpp zombie_attack_01.cpp zombie_attack_02.cpp zombie_attack_03.cpp zombie_attack_04.cpp zombie_attack_05.cpp zombie_attack_06.cpp zombie_attack_07.cpp zombie_dead_00.cpp zombie_dead_01.cpp zombie_dead_02.cpp zombie_dead_03.cpp zombie_dead_04.cpp zombie_dead_05.cpp zombie_dead_06.cpp zombie_dead_07.cpp Zombie_walk_00.cpp Zombie_walk_01.cpp Zombie_walk_02.cpp Zombie_walk_03.cpp Zombie_walk_04.cpp Zombie_walk_05.cpp Zombie_walk_06.cpp Zombie_walk_07.cpp Zombie_walk_08.cpp Zombie_walk_09.cpp
    ../Gui/generated/images/src/Game2048/: auto_play_button.cpp auto_play_button_pressed.cpp game_2048_background.cpp game_2048_dot_off.cpp game_2048_dot_on.cpp game_2048_game_over.cpp game_2048_menu_button.cpp game_2048_menu_button_pressed.cpp game_2048_you_win.cpp how_to_play_00.cpp how_to_play_01.cpp how_to_play_02.cpp how_to_play_background.cpp how_to_play_button.cpp how_to_play_button_pressed.cpp how_to_play_close_button.cpp new_game_button.cpp new_game_button_pressed.cpp tile_0002.cpp tile_0004.cpp tile_0008.cpp tile_0016.cpp tile_0032.cpp tile_0064.cpp tile_0128.cpp tile_0256.cpp tile_0512.cpp tile_1024.cpp tile_2048.cpp
    ../Gui/generated/images/src/Common/: back.cpp common_player_bar.cpp overlay_background_shadow.cpp
    ../Gui/generated/images/src/Movie/: back_bar.cpp back_button.cpp back_button_pressed.cpp back_icon.cpp browse_folder_listitem_bar.cpp browse_folder_listitem_bar_selected.cpp browse_folder_navi_bar.cpp browse_folder_shadow_bottom.cpp browse_folder_shadow_right.cpp browse_folder_shadow_top.cpp browse_folder_title_bar.cpp default_background.cpp directory.cpp document.cpp done_button.cpp done_button_pressed.cpp empty_slot.cpp folder.cpp folder_icon_pressed.cpp folder_large.cpp folder_large_pressed.cpp grid.cpp grid_background.cpp grid_large.cpp grid_large_pressed.cpp grid_pressed.cpp loop.cpp loop_active.cpp menu_icon_white.cpp minus.cpp pause.cpp play.cpp play_overlay_grid.cpp plus.cpp selected.cpp time_line.cpp time_line_active.cpp toggle_off.cpp toggle_on.cpp up_button.cpp up_button_pressed.cpp
    ../Gui/generated/images/src/Audio/: back_notPressed.cpp back_Pressed.cpp fore_not_pressed.cpp fore_pressed.cpp pause_notPressed.cpp pause_pressed.cpp play_notPressed.cpp play_Pressed1.cpp stop_notPressed.cpp stop_Pressed.cpp
    ../Gui/generated/images/src/: BitmapDatabase.cpp
    ../Gui/generated/images/src/HomeAutomation/: blinds_icon_32.cpp home_automation_background.cpp home_back_button.cpp home_back_button_pressed.cpp home_login_background.cpp home_room_image_00.cpp home_room_image_01.cpp home_room_image_02.cpp home_room_image_03.cpp home_room_image_04.cpp home_room_image_05.cpp home_room_image_06.cpp home_room_image_07.cpp home_room_image_08.cpp home_room_image_09.cpp home_room_selected_light.cpp home_room_selected_lock.cpp lights_icon_32.cpp lock_icon_32.cpp main_button_blinds.cpp main_button_blinds_pressed.cpp main_button_light.cpp main_button_light_pressed.cpp main_button_security.cpp main_button_security_pressed.cpp main_button_statistics.cpp main_button_statistics_pressed.cpp statistics_gradient_blue.cpp statistics_gradient_blue_line.cpp statistics_gradient_green.cpp statistics_gradient_green_line.cpp statistics_gradient_red.cpp statistics_gradient_red_line.cpp statistics_lower.cpp statistics_upper.cpp
    ../Gui/generated/images/src/Controls/clock/: blue_glow.cpp clock_00_background.cpp clock_00_hour_hand.cpp clock_00_minute_hand.cpp clock_00_second_hand.cpp clock_01_background.cpp clock_01_hour_hand.cpp clock_01_minute_hand.cpp clock_01_second_hand.cpp clock_02_background.cpp clock_02_hour_hand.cpp clock_02_minute_hand.cpp clock_02_second_hand.cpp
    ../Gui/generated/images/src/Controls/: board_image.cpp clock_settings_AM.cpp clock_settings_circle.cpp clock_settings_circleSelected.cpp clock_settings_colon.cpp clock_settings_PM.cpp control_line_indicator.cpp controls_2dots.cpp controls_3dots.cpp controls_background.cpp date_picker_background.cpp date_picker_bar.cpp date_picker_shadow_bottom.cpp date_picker_shadow_top.cpp dot_indicator_.cpp dot_indicator_highlighted.cpp icon_brightness_large.cpp icon_brightness_small.cpp menu_icon.cpp menu_icon_pressed.cpp settings_button.cpp settings_button_pressed.cpp settings_calendar.cpp settings_done.cpp settings_done_pressed.cpp settings_next.cpp settings_next_pressed.cpp slider.cpp slider_full.cpp slider_knop.cpp value_indicator_arrow.cpp value_indicator_circle.cpp value_indicator_glow.cpp value_indicator_wheel.cpp
    ../Gui/generated/images/src/BumpMap/: bump_map_next_button.cpp bump_map_next_button_pressed.cpp new_light_effect_image.cpp touchgfx_light_effect.cpp
    ../Gui/generated/images/src/CarouselMenu/: carousel_background.cpp carousel_menu_icons_2048_large.cpp carousel_menu_icons_2048_medium.cpp carousel_menu_icons_2048_small.cpp carousel_menu_icons_audio_player_large.cpp carousel_menu_icons_audio_player_medium.cpp carousel_menu_icons_audio_player_small.cpp carousel_menu_icons_bump_map_large.cpp carousel_menu_icons_bump_map_medium.cpp carousel_menu_icons_bump_map_small.cpp carousel_menu_icons_controls_large.cpp carousel_menu_icons_controls_medium.cpp carousel_menu_icons_controls_small.cpp carousel_menu_icons_home_automation_large.cpp carousel_menu_icons_home_automation_medium.cpp carousel_menu_icons_home_automation_small.cpp carousel_menu_icons_knight_large.cpp carousel_menu_icons_knight_medium.cpp carousel_menu_icons_knight_small.cpp carousel_menu_icons_settings_large.cpp carousel_menu_icons_settings_medium.cpp carousel_menu_icons_settings_small.cpp carousel_menu_icons_video_player_large.cpp carousel_menu_icons_video_player_medium.cpp carousel_menu_icons_video_player_small.cpp menu_toggle_button.cpp menu_toggle_button_pressed.cpp st_menu_button.cpp st_menu_button_pressed.cpp
    ../Gui/generated/images/src/HomeAutomation/login/: login_node_00.cpp login_node_01.cpp login_node_02.cpp login_node_03.cpp login_node_04.cpp login_node_05.cpp login_node_06.cpp login_node_07.cpp login_node_08.cpp login_node_09.cpp login_node_10.cpp login_node_11.cpp login_node_12.cpp login_node_13.cpp login_node_14.cpp login_node_15.cpp login_node_16.cpp login_node_17.cpp login_node_18.cpp login_node_19.cpp login_node_20.cpp login_node_21.cpp login_node_22.cpp login_node_23.cpp login_node_24.cpp login_node_25.cpp login_node_26.cpp login_node_27.cpp login_node_28.cpp
  group Application/User/TouchGFX/texts
    ../Gui/generated/texts/src/: LanguageGbr.cpp Texts.cpp TypedTextDatabase.cpp
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
    ../../../../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STM32H743I-EVAL
    ../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_audio.c stm32h743i_eval_bus.c stm32h743i_eval_io.c stm32h743i_eval_lcd.c stm32h743i_eval_qspi.c stm32h743i_eval_sd.c stm32h743i_eval_sdram.c stm32h743i_eval_ts.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx_singlecore.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Middleware/FatFS
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middleware/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middleware/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middleware/Libjpeg
    ../../../../../Middlewares/Third_Party/LibJPEG/source/: jaricom.c jcomapi.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group Middleware/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middleware/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Middleware/TouchGFX/Target
    ../Gui/target/: BoardConfiguration.cpp EXC7200TouchController.cpp GPIO.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp
  group Utilities/JPEG
    ../../../../../Utilities/JPEG/: jpeg_utils.c
  group Middleware/Addons/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
  group Doc
    ../: readme.txt
target TouchGFX-STM32H743I_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: as above
  output: TouchGFX-STM32H743I-EVAL_V1.1.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: as above
  c misc: --diag_suppress 1300
  c include: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x16ffff
  memory RVCT5: ROM 0x8170000 size 0x90000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\TouchGFX-STM32H743I-EVAL.sct
software components: CMSIS:CORE 4.3.0
