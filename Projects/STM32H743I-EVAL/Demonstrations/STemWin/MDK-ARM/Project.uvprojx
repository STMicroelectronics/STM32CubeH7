# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.3
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x24000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743I_EVAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H743I_EVAL,USE_IOEXPANDER,CORE_CM7,CH7
  c include: ../Gui/STemWin_Addons;../Config;../Core/inc;../../../../../Utilities/CPU;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32H743I_EVAL;../../../../../Drivers/BSP/Components;../../../../../Drivers/BSP/Components/Common;../../../../../Middlewares/ST/STemWin/inc;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../Middlewares/Third_Party/LwIP/system;../../../../../Middlewares/Third_Party/LwIP/system/OS;../Modules/Common;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../Gui/Target;../Gui/Core/video_player;../Modules/audio_player;../Modules/video_player
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: STM32H743I_EVAL\Exe\STM32H743I_EVAL.sct
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: unicode.c syscall.c
  group Application/User/Gui/graphic_effect
    ../Gui/Core/graphic_effect/: graphic_effects_win.c filtring.c
  group Application/User/Modules/common
    ../Modules/Common/: audio_if.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STemWin_Addon_CM7_wc16.a
  group Drivers/BSP/STM32H747I_EVAL
    ../../../../../Drivers/BSP/STM32H743I_EVAL/: stm32h743i_eval_io.c stm32h743i_eval_audio.c stm32h743i_eval_sd.c stm32h743i_eval_sdram.c stm32h743i_eval_qspi.c stm32h743i_eval_ts.c stm32h743i_eval.c
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
  group Application/User/Gui/settings
    ../Gui/Core/settings/: settings_win.c
  group Application/User/Core
    ../Core/Src/: stm32h7xx_hal_timebase_tim.c k_menu.c k_storage.c k_bsp.c k_rtc.c stm32h7xx_it.c k_module.c main.c
  group Middlewares/FatFs/Drivers
    ../Config/: sd_diskio.c
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../: readme.txt
  group Application/User/Gui/games
    ../Gui/Core/games/: rocket_game_win.c
  group Drivers/STM32H7xx_HAL_Drivers
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_gpio.c stm32h7xx_hal_lptim.c stm32h7xx_hal_sai_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_usart.c stm32h7xx_hal_uart.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_nand.c stm32h7xx_hal_hcd.c stm32h7xx_hal_cryp.c stm32h7xx_hal_sai.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_sram.c stm32h7xx_hal.c stm32h7xx_hal_tim.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_dac.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pcd.c stm32h7xx_hal_adc.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_adc_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_i2c.c stm32h7xx_hal_rtc.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_sdram.c stm32h7xx_hal_rcc.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_usart_ex.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c tasks.c timers.c event_groups.c queue.c croutine.c
  group Application/User/Gui/video_player
    ../Gui/Core/video_player/: jpeg_utils.c video_player_win.c
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc16_ot_ARGB.a
  group Application/User/Gui/analog_clock
    ../Gui/Core/anolog_clock/: analog_clock_win.c
  group Application/User/Modules/video_player
    ../Modules/video_player/: GUI_AVI.c video_player_app.c
  group Application/User/Modules/audio_player
    ../Modules/audio_player/: audio_player_app.c
  group Application/User/Gui/audio_player
    ../Gui/Core/audio_player/: visualization.c audio_player_win.c
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
software components: CMSIS:CORE 4.3.0
