# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.9
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743I_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx, USE_STM32H743I_EVAL,USE_IOEXPANDER
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32H743I_EVAL;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/Fonts;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../Drivers/BSP/STM32H743I_EVAL/: stm32h743i_eval_io.c stm32h743i_eval_ts.c stm32h743i_eval_sd.c stm32h743i_eval.c stm32h743i_eval_lcd.c stm32h743i_eval_sdram.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/exc7200/: exc7200.c
    ../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../Drivers/BSP/Components/ts3510/: ts3510.c
    ../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../../../Drivers/BSP/Components/wm8994/: wm8994.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_sd.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_mdios.c stm32h7xx_hal_pcd.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dac.c stm32h7xx_hal_hash_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_uart.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_sram.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_smbus.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nand.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_crc.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_lptim.c stm32h7xx_hal_usart.c stm32h7xx_hal_rtc.c stm32h7xx_hal_nor.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal.c stm32h7xx_hal_hsem.c stm32h7xx_hal_spi.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_comp.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_i2c.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_tim.c stm32h7xx_hal_hcd.c stm32h7xx_hal_sai.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_cryp.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_opamp.c stm32h7xx_hal_qspi.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_eth.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_hash.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sdram.c stm32h7xx_hal_dma.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_ramecc.c
  group Example/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Example/User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
