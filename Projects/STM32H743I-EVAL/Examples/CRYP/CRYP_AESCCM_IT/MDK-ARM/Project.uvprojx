# Keil uVision project Project.uvprojx, settings and files
target STM32H753I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H753XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x80000) IRAM2(0x24000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H753I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H753xx, USE_STM32H743I_EVAL,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Drivers/BSP/STM32H743I-EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval_io.c stm32h743i_eval.c stm32h743i_eval_bus.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_dma.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_exti.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Example/MDK-ARM
    ../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h753xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Example/User
    ../Src/: stm32h7xx_it.c main.c stm32h7xx_hal_msp.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
