# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743I_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H743I_EVAL
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: STM32H743I_EVAL\STM32H743I_EVAL.sct
  group Drivers/BSP/STM32H743I-EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_bus.c stm32h743i_eval_io.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_uart.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_adc.c stm32h7xx_hal_dma.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_exti.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_pwr.c
  group Example/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Middlewares/PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
  group Example/User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
