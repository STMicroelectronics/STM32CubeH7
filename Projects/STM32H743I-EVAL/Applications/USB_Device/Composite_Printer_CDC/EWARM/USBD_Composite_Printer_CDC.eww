<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\USBD_Composite_Printer_CDC.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Build_All</name>
            <member>
                <project>USBD_CDC</project>
                <configuration>STM32756G-EVAL_USBD-FS</configuration>
            </member>
            <member>
                <project>USBD_CDC</project>
                <configuration>STM32756G-EVAL_USBD-HS</configuration>
            </member>
            <member>
                <project>USBD_CDC</project>
                <configuration>STM32756G-EVAL_USBD-HS-IN-FS</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
