<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\USBD_AUDIO.ewp</path>
  </project>
  <batchBuild />
</workspace>
