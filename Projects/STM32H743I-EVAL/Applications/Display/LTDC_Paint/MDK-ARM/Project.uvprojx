# Keil uVision project Project.uvprojx, settings and files
target STM32H743I-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743I-EVAL +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H743xx,USE_HAL_DRIVER,USE_USB_HS,USE_IOEXPANDER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Utilities/Fonts;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities;../../../../../../Utilities/Basic_GUI;../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_HOST_Library/Class/MSC/Inc;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc_scsi.c usbh_msc.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval_sdram.c stm32h743i_eval.c stm32h743i_eval_ts.c stm32h743i_eval_io.c stm32h743i_eval_bus.c stm32h743i_eval_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Application/User
    ../Src/: usbh_conf.c main.c ts_calibration.c stm32h7xx_it.c usbh_diskio.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_flash.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_mdma.c stm32h7xx_ll_usb.c stm32h7xx_ll_fmc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_dma.c stm32h7xx_hal_rcc.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_uart.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_exti.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ctlreq.c usbh_pipes.c usbh_ioreq.c usbh_core.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Utilities
    ../../../../../../Utilities/Basic_GUI/: basic_gui.c
software components: CMSIS:CORE 4.3.0
