# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: STMicroelectronics.STM32H7xx_DFP.0.0.9
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x24000000,0x80000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743I_EVAL
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_IOEXPANDER,STM32H743xx,USE_STM32H743I_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/LibJPEG/include;..\..\..\..\..\..\Utilities\Basic_GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
    ../../../../../../Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
  group Drivers/BSP/STM32H743_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_lcd.c stm32h743i_eval_io.c stm32h743i_eval_bus.c stm32h743i_eval_sd.c stm32h743i_eval_sdram.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Middlewares/Lib_JPEG
    ../../../../../../Middlewares/Third_Party/LibJPEG/source/: jcapistd.c jdpostct.c jidctflt.c jcsample.c jutils.c jfdctflt.c jdcolor.c jddctmgr.c jaricom.c jdmarker.c jdapimin.c jquant1.c jdmainct.c jcparam.c jdcoefct.c jdinput.c jcdctmgr.c jmemnobs.c jdapistd.c jcomapi.c jidctint.c jquant2.c jcmaster.c jdtrans.c jfdctint.c jctrans.c jfdctfst.c jcinit.c jcmarker.c jcarith.c jcapimin.c jccoefct.c jerror.c jcprepct.c jdhuff.c jmemmgr.c jdatadst.c jdmaster.c jdarith.c jdmerge.c jchuff.c jcmainct.c jdatasrc.c jdsample.c jccolor.c jidctfst.c
  group Application/User
    ../Src/: jdata_conf.c main.c decode.c sd_diskio.c stm32h7xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_sdram.c stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma.c stm32h7xx_hal_mdma.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_pwr.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_i2c.c stm32h7xx_ll_fmc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_sd.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_i2c_ex.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../../../Utilities/Basic_GUI/: basic_gui.c
software components: CMSIS:CORE 5.0.1
