<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build_All</name>
      <member>
        <project>FatFS_USBDisk_Standalone</project>
        <configuration>STM32H743I-EVAL_USBH-FS</configuration>
      </member>
      <member>
        <project>FatFS_USBDisk_Standalone</project>
        <configuration>STM32H743I-EVAL_USBH-HS</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


