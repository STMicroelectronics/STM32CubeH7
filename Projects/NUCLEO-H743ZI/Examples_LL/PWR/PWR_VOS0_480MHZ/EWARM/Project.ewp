# IAR project Project.ewp, settings and files
configuration STM32H743ZI_Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PWR_Project.hex
  ILINK.IlinkOutputFile: STM32H743ZI_NUCLEO.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_LL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32h743xx.s
  group Example/User
    ../Src/: main.c stm32h7xx_it.c
