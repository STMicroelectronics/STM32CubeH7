# Keil uVision project Project.uvprojx, settings and files
target STM32H743ZI-Nucleo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.1.0.7
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32H743ZI-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx, USE_STM32H7XX_NUCLEO_144_MB1364
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H7xx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_gpio.c stm32h7xx_hal_exti.c stm32h7xx_hal_dac.c stm32h7xx_hal_flash.c stm32h7xx_hal_i2c.c stm32h7xx_hal_rcc.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Example/MDK-ARM
    ./: startup_stm32h743xx.s
  group Example/User
    ../Src/: stm32h7xx_hal_msp.c main.c stm32h7xx_it.c
  group Drivers/BSP/STM32H743ZI-Nucleo
    ../../../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 4.3.0
