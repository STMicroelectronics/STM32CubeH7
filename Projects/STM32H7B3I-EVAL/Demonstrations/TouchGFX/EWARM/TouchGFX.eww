<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\TouchGFX.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>everything</name>
            <member>
                <project>TouchGFX</project>
                <configuration>TouchGFX-STM32H747I-DISCO_OoB</configuration>
            </member>
            <member>
                <project>TouchGFX</project>
                <configuration>TouchGFX-STM32H747I-DISCO</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
