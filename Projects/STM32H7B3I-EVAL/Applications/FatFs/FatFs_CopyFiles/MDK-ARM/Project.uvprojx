# Keil uVision project Project.uvprojx, settings and files
target STM32H7B3I_EVAL_FatFs_CopyFiles (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3NIHxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.4
  cpu: IROM(0x08000000-0x81FFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM(0x0-0xFFFFFFFFFFFFFFFF) IROM2(0x0-0xFFFFFFFFFFFFFFFF) IROM3(0x0-0xFFFFFFFFFFFFFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7B3I_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H7B3xxQ,USE_STM32H7B3I_EVAL
  c include: ../Core/Inc;../FatFs/App;../FatFs/Target;../../../../../../Drivers/BSP/STM32H7B3I-EVAL;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/Core
    ../Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Application/FatFs/App
    ../FATFS/App/: app_fatfs.c
  group Application/FatFs/Target
    ../FATFS/Target/: sd_diskio1.c sd_diskio2.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32H7B3I-EVAL
    ../../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_io.c stm32h7b3i_eval_sd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
software components: CMSIS:CORE 4.3.0
