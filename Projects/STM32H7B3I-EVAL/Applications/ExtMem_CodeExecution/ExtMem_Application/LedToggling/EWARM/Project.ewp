# IAR project Project.ewp, settings and files
configuration XIP_NOR_InternalSRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7B3I-EVAL ST STM32H7B3I-EVAL
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x60000000U; USE_HAL_DRIVER; STM32H7B0xxQ; USE_STM32H7B3I_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32H7B3I-EVAL; ..\..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: STM32H7B3I_EVAL.out
  ILINK.IlinkIcfFile: NORflash_InternalSRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration XIP_NOR_ExternalSRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: NORflash_ExternalSRAM.icf
configuration XIP_NOR_ExternalSDRAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: NORflash_ExternalSDRAM.icf
configuration BootROM_ExternalSRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x68000000U; USE_HAL_DRIVER; STM32H7B0xxQ; USE_STM32H7B3I_EVAL
  ILINK.IlinkIcfFile: ExternalSRAM_InternalSRAM.icf
configuration BootROM_ExternalSDRAM_InternalSRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0xD0000000U; USE_HAL_DRIVER; STM32H7B0xxQ; USE_STM32H7B3I_EVAL
  ILINK.IlinkIcfFile: ExternalSDRAM_InternalSRAM.icf
configuration XIP_OSPI_Internal_SRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x90000000U; STM32H7B0xxQ; USE_HAL_DRIVER; USE_STM32H7B3I_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\\STM32H7B3I-EVAL; ..\..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common
  ILINK.IlinkIcfFile: OSPIflash_InternalSRAM.icf
configuration XIP_OSPI_External_SRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: OSPIflash_ExternalSRAM.icf
configuration XIP_OSPI_External_SDRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: APPLICATION_ADDRESS=0x90000000U; STM32H7B0xxQ; USE_HAL_DRIVER; USE_STM32H7B3I_EVAL; USE_IOEXPANDER
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: OSPIflash_ExternalSDRAM.icf
  group Application/EWARM
    ./: startup_stm32h7b0xxq.s
  group Application/User
    ../Src/: main.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/Components
    ../../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/STM32H7B3I_EVAL
    ../../../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_io.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c
