# IAR project Project.ewp, settings and files
configuration STM32H7B3I_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7B3LI-Q ST STM32H7B3LI-Q
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7B3xxQ
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\BSP\STM32H7B3I-EVAL; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Utilities\Basic_GUI
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H7B3I_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32h7b3xxq_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/CS42L51
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
  group Drivers/BSP/Components/FT5336
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/BSP/Components/IS42S32800J
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/Components/M24LR64
    ../../../../../Drivers/BSP/Components/m24lr64/: m24lr64.c
  group Drivers/BSP/Components/MFXSTM32L152
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/Components/MX25LM51245G
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/Components/OV5640
    ../../../../../Drivers/BSP/Components/ov5640/: ov5640.c ov5640_reg.c
  group Drivers/BSP/Components/S5K5CAG
    ../../../../../Drivers/BSP/Components/s5k5cag/: s5k5cag.c s5k5cag_reg.c
  group Drivers/BSP/STM32H7B3I_EVAL
    ../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_audio.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_camera.c stm32h7b3i_eval_eeprom.c stm32h7b3i_eval_io.c stm32h7b3i_eval_lcd.c stm32h7b3i_eval_nor.c stm32h7b3i_eval_ospi.c stm32h7b3i_eval_sd.c stm32h7b3i_eval_sdram.c stm32h7b3i_eval_sram.c stm32h7b3i_eval_ts.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Example/EWARM
    ./: startup_stm32h7b3xxq.s
  group Example/User
    ../Src/: audio_loopback.c audio_play.c camera.c eeprom.c lcd.c main.c nor.c octospi.c potentiometer.c sd.c sdram.c sram.c stm32h7xx_it.c touchscreen.c
  group Utilities
    ../../../../../Utilities/Basic_GUI/: basic_gui.c
