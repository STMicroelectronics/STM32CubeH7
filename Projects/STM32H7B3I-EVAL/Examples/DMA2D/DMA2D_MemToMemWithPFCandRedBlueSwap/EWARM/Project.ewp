# IAR project Project.ewp, settings and files
configuration STM32H7B3I_EVAL_DMA2D_MemToMemWithPFCandRedBlueSwap (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7B3LI-Q ST STM32H7B3LI-Q
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7B3xxQ; USE_STM32H7B3I_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H7B3I-EVAL; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Utilities\Fonts; ..\..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\..\Utilities\Basic_GUI; ..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32H7B3I_EVAL.out
  ILINK.IlinkIcfFile: stm32h7b3xxq_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Example/EWARM
    ./: startup_stm32h7b3xxq.s
  group Drivers/BSP/STM32H7B3I-EVAL
    ../../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_io.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_sdram.c stm32h7b3i_eval_lcd.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sdram.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Utilities
    ../../../../../../Utilities/Basic_GUI/: basic_gui.c
