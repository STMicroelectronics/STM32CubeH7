# Keil uVision project Project.uvprojx, settings and files
target STM32H7B3I_EVAL_SD_ReadWrite_IT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H7B3I_EVAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H7B3xxQ,USE_STM32H7B3I_EVAL
  c include: ../Inc;../../../../../../Drivers/BSP/STM32H7B3I-EVAL;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/Basic_GUI;../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: STM32H7B3I_EVAL\Exe\STM32H7B3I_EVAL.sct
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/STM32H7B3I-EVAL
    ../../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_io.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c
  group Example/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Example/User
    ../Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
software components: CMSIS:CORE 5.2.0
