# IAR project Project.ewp, settings and files
configuration STM32H723ZG_Nucleo_SPI_OneBoard_HalfDuplex_DMA_Init (ARM, debug)
  General.OGChipSelectEditMenu: STM32H723ZG ST STM32H723ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32H723xx; HSE_VALUE=8000000U
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_OneBoard_HalfDuplex_DMA_Init.hex
  ILINK.IlinkOutputFile: STM32H723ZG_NUCLEO.out
  ILINK.IlinkIcfFile: stm32h723xx_flash_rw_axisram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_LL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_rcc.c stm32h7xx_ll_spi.c stm32h7xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32h723xx.s
  group Example/User
    ../Src/: main.c stm32h7xx_it.c
