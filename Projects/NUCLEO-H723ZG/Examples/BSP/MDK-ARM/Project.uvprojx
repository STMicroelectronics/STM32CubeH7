# Keil uVision project Project.uvprojx, settings and files
target STM32H723ZG_Nucleo_BSP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.2
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H723ZG_Nucleo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx
  c include: ../Inc;../../../../../Drivers/BSP/Adafruit_Shield;../../../../../Drivers/BSP/STM32H7xx_Nucleo;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/Common;../../../../../Utilities/Fonts;../../../../../Utilities/CPU;../../../../../Utilities/lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  group Doc
    ../: readme.txt
  group Drivers/BSP/Adafruit_Shield
    ../../../../../Drivers/BSP/Adafruit_Shield/: adafruit_802.c adafruit_802_lcd.c adafruit_802_sd.c
  group Drivers/BSP/Components/ST7735
    ../../../../../Drivers/BSP/Components/st7735/: st7735.c st7735_reg.c
  group Drivers/BSP/STM32H7xx_Nucleo
    ../../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_uart.c
  group Example/MDK-ARM
    ./: startup_stm32h723xx.s
  group Example/User
    ../Src/: joystick.c lcd.c main.c sd.c stm32h7xx_it.c stm32h7xx_nucleo_bus.c
  group Utilities
    ../../../../../Utilities/lcd/: stm32_lcd.c
