# IAR project Project.ewp, settings and files
configuration STM32H723ZG_Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32H723ZG ST STM32H723ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; STM32H723xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Templates_LL.hex
  ILINK.IlinkOutputFile: STM32H723ZG_Nucleo.out
  ILINK.IlinkIcfFile: stm32h723xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_LL_Driver
    ../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_gpio.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32h723xx.s
  group Example/User
    ../Src/: main.c stm32h7xx_it.c
