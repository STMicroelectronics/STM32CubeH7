# IAR project Project.ewp, settings and files
configuration STM32H7A3ZIQ_Nucleo_DMA2D_MemToMemWithLCD (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7A3ZI-Q ST STM32H7A3ZI-Q
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7A3xxQ; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H7xx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\Adafruit_Shield; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32H7A3ZIQ_NUCLEO.out
  ILINK.IlinkIcfFile: stm32h7a3xxq_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_nucleo_bus.c
  group Example/EWARM
    ./: startup_stm32h7a3xxq.s
  group Drivers/BSP/STM32H7xx_Nucleo
    ../../../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Drivers/BSP/Adafruit_Shield
    ../../../../../../Drivers/BSP/Adafruit_Shield/: adafruit_802.c adafruit_802_lcd.c
  group Drivers/BSP/Components/ST7735
    ../../../../../../Drivers/BSP/Components/st7735/: st7735.c st7735_reg.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_ll_dma2d.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
