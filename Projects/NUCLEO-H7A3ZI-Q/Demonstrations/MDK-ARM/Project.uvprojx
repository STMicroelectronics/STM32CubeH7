# Keil uVision project Project.uvprojx, settings and files
target STM32H7A3ZI_Nucleo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7A3ZITxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7A3ZI_Nucleo
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7A3xxQ
  c include: ../Inc;../../../../Drivers/BSP/STM32H7xx_Nucleo;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../Drivers/BSP/Components/Common;../../../../Drivers/BSP/Adafruit_Shield;../../../../Utilities/Fonts;../../../../Utilities/BASIC_GUI;../../../../Middlewares/Third_Party/FatFs/src;../../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h7a3xxq.s
  group Application/User
    ../Src/: fatfs_storage.c main.c sd_diskio.c stm32h7xx_it.c stm32h7xx_nucleo_bus.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Adafruit_Shield
    ../../../../Drivers/BSP/Adafruit_Shield/: adafruit_802.c adafruit_802_lcd.c adafruit_802_sd.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/st7735/: st7735.c st7735_reg.c
  group Drivers/BSP/STM32H7xx_Nucleo
    ../../../../Drivers/BSP/STM32H7xx_Nucleo/: stm32h7xx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c
  group Middlewares/FatFS/Core
    ../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFS/Options
    ../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Utilities
    ../../../../Utilities/Basic_GUI/: basic_gui.c
software components: CMSIS:CORE 4.3.0
