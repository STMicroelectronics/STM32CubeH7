# Keil uVision project Project.uvprojx, settings and files
target STM32H7A3ZIQ_Nucleo_SPI_FullDuplex_ComIT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7A3ZITxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: STM32H7A3ZIQ_NUCLEO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32H7A3xxQ
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c stm32h7xx_it.c
  group Example/MDK-ARM
    ./: startup_stm32h7a3xxq.s
  group Drivers/STM32H7xx_LL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_utils.c stm32h7xx_ll_gpio.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_spi.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
software components: CMSIS:CORE 4.3.0
