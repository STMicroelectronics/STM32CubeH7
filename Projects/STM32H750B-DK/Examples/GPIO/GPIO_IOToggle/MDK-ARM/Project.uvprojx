# Keil uVision project Project.uvprojx, settings and files
target XIP_QSPI_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) XRAM3(0x00000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,USE_HAL_DRIVER, STM32H750xx,USE_STM32H750B_DISCO
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32H750B-Discovery;../../../../../../Drivers/BSP/Components/Common;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Example/MDK-ARM
    ./: startup_stm32h750xx.s
  group Example/User
    ../Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_uart_ex.c
target XIP_QSPI_ExternalSDRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.3
  cpu: as above
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0x90000000U,USE_HAL_DRIVER, STM32H750xx,USE_STM32H750B_DISCO,USE_IOEXPANDER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x90000000 size 0x8000000
  memory RVCT9: RAM 0xd0000000 size 0x800000
target BootROM_ExternalSDRAM_InternalSRAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.3
  cpu: as above
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APPLICATION_ADDRESS=0xD0000000U,USE_HAL_DRIVER,STM32H750xx,USE_STM32H750B_DISCO,USE_EXTERNAL_SDRAM,USE_IOEXPANDER
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0xd0000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.1.1
