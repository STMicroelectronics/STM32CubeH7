<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STemWin.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>everything</name>
            <member>
                <project>STemWin</project>
                <configuration>STemWin-STM32H750B-DK_OoB</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
