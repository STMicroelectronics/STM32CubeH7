# Keil uVision project TouchGFX.uvprojx, settings and files
target TouchGFX-STM32H750B-DK_OoB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TouchGFX-STM32H750B-DK_OoB_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ST,STM32H750xx,USE_STM32H750B_DK,BSP_USE_CMSIS_OS,VECT_TAB_QSPI,USE_HAL_DRIVER,USE_BPP=24,USE_USB_FS
  c misc: --diag_suppress 1300
  c include: ../Config;../Gui/gui/include;../Gui/generated/fonts/include;../Gui/generated/images/include;../Gui/generated/texts/include;../Gui/generated/gui_generated/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32H750B-DK;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Gui/target;../Core/Inc;../../../../../Drivers/CMSIS/Include;../Gui/widgets/include;../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../Utilities/JPEG;../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/BSP/Components/Common
  asm include: ../Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: TouchGFX-STM32H750B-DK_OoB\Exe\TouchGFX-STM32H750B-DK_OoB_V1.0.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s Media.s
  group Application/User/Core
    ../Core/Src/: bsp.c FatFSFileInput.cpp hwjpeg_decode.c main.cpp stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c usbh_conf.c
    ../../../../../Utilities/JPEG/: jpeg_utils.c
  group Application/User/TouchGFX/generated/fonts
    ../Gui/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Asap_Bold_10_4bpp_0.cpp Font_Asap_Bold_12_4bpp_0.cpp Font_Asap_Bold_14_4bpp_0.cpp Font_Asap_Bold_16_4bpp_0.cpp Font_Asap_Bold_18_4bpp_0.cpp Font_Asap_Bold_20_4bpp_0.cpp Font_Asap_Bold_22_4bpp_0.cpp Font_Asap_Bold_24_4bpp_0.cpp Font_Asap_Bold_25_4bpp_0.cpp Font_Asap_Bold_26_4bpp_0.cpp Font_Asap_Bold_40_4bpp_0.cpp Font_Asap_Bold_60_4bpp_0.cpp Font_Asap_Bold_94_4bpp_0.cpp Font_Asap_Regular_26_4bpp_0.cpp Font_Exo2_Medium_18_4bpp_0.cpp Font_Exo2_Medium_24_4bpp_0.cpp Font_Exo2_Medium_26_4bpp_0.cpp Font_Exo2_Medium_30_4bpp_0.cpp Font_Exo2_Medium_34_4bpp_0.cpp Font_Exo2_Medium_40_4bpp_0.cpp Font_Exo2_Medium_80_4bpp_0.cpp Font_Exo2_SemiBold_25_4bpp_0.cpp Font_OpenSans_Italic_20_4bpp_0.cpp Font_OpenSans_Regular_10_4bpp_0.cpp Font_OpenSans_Regular_16_4bpp_0.cpp Font_OpenSans_Regular_16_4bpp_4.cpp Font_OpenSans_Semibold_14_4bpp_0.cpp Font_OpenSans_Semibold_18_4bpp_0.cpp Font_OpenSans_Semibold_20_4bpp_0.cpp Font_OpenSans_Semibold_23_4bpp_0.cpp Font_OpenSans_Semibold_26_4bpp_0.cpp Font_OpenSans_SemiboldItalic_13_4bpp_0.cpp Font_SairaCondensed_Medium_14_4bpp_0.cpp Font_SairaCondensed_Medium_16_4bpp_0.cpp Font_SairaCondensed_Medium_20_4bpp_0.cpp Font_SairaCondensed_Medium_22_4bpp_0.cpp Font_SairaCondensed_Medium_28_4bpp_0.cpp Font_SairaCondensed_SemiBold_12_4bpp_0.cpp Font_SairaCondensed_SemiBold_14_4bpp_0.cpp Font_SairaCondensed_SemiBold_16_4bpp_0.cpp Font_SairaCondensed_SemiBold_20_4bpp_0.cpp Font_SairaSemiCondensed_Medium_34_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Asap_Bold_10_4bpp.cpp Kerning_Asap_Bold_12_4bpp.cpp Kerning_Asap_Bold_14_4bpp.cpp Kerning_Asap_Bold_16_4bpp.cpp Kerning_Asap_Bold_18_4bpp.cpp Kerning_Asap_Bold_20_4bpp.cpp Kerning_Asap_Bold_22_4bpp.cpp Kerning_Asap_Bold_24_4bpp.cpp Kerning_Asap_Bold_25_4bpp.cpp Kerning_Asap_Bold_26_4bpp.cpp Kerning_Asap_Bold_40_4bpp.cpp Kerning_Asap_Bold_60_4bpp.cpp Kerning_Asap_Bold_94_4bpp.cpp Kerning_Asap_Regular_26_4bpp.cpp Kerning_Exo2_Medium_18_4bpp.cpp Kerning_Exo2_Medium_24_4bpp.cpp Kerning_Exo2_Medium_26_4bpp.cpp Kerning_Exo2_Medium_30_4bpp.cpp Kerning_Exo2_Medium_34_4bpp.cpp Kerning_Exo2_Medium_40_4bpp.cpp Kerning_Exo2_Medium_80_4bpp.cpp Kerning_Exo2_SemiBold_25_4bpp.cpp Kerning_OpenSans_Italic_20_4bpp.cpp Kerning_OpenSans_Regular_10_4bpp.cpp Kerning_OpenSans_Regular_16_4bpp.cpp Kerning_OpenSans_Semibold_14_4bpp.cpp Kerning_OpenSans_Semibold_18_4bpp.cpp Kerning_OpenSans_Semibold_20_4bpp.cpp Kerning_OpenSans_Semibold_23_4bpp.cpp Kerning_OpenSans_Semibold_26_4bpp.cpp Kerning_OpenSans_SemiboldItalic_13_4bpp.cpp Kerning_SairaCondensed_Medium_14_4bpp.cpp Kerning_SairaCondensed_Medium_16_4bpp.cpp Kerning_SairaCondensed_Medium_20_4bpp.cpp Kerning_SairaCondensed_Medium_22_4bpp.cpp Kerning_SairaCondensed_Medium_28_4bpp.cpp Kerning_SairaCondensed_SemiBold_12_4bpp.cpp Kerning_SairaCondensed_SemiBold_14_4bpp.cpp Kerning_SairaCondensed_SemiBold_16_4bpp.cpp Kerning_SairaCondensed_SemiBold_20_4bpp.cpp Kerning_SairaSemiCondensed_Medium_34_4bpp.cpp Table_Asap_Bold_10_4bpp.cpp Table_Asap_Bold_12_4bpp.cpp Table_Asap_Bold_14_4bpp.cpp Table_Asap_Bold_16_4bpp.cpp Table_Asap_Bold_18_4bpp.cpp Table_Asap_Bold_20_4bpp.cpp Table_Asap_Bold_22_4bpp.cpp Table_Asap_Bold_24_4bpp.cpp Table_Asap_Bold_25_4bpp.cpp Table_Asap_Bold_26_4bpp.cpp Table_Asap_Bold_40_4bpp.cpp Table_Asap_Bold_60_4bpp.cpp Table_Asap_Bold_94_4bpp.cpp Table_Asap_Regular_26_4bpp.cpp Table_Exo2_Medium_18_4bpp.cpp Table_Exo2_Medium_24_4bpp.cpp Table_Exo2_Medium_26_4bpp.cpp Table_Exo2_Medium_30_4bpp.cpp Table_Exo2_Medium_34_4bpp.cpp Table_Exo2_Medium_40_4bpp.cpp Table_Exo2_Medium_80_4bpp.cpp Table_Exo2_SemiBold_25_4bpp.cpp Table_OpenSans_Italic_20_4bpp.cpp Table_OpenSans_Regular_10_4bpp.cpp Table_OpenSans_Regular_16_4bpp.cpp Table_OpenSans_Semibold_14_4bpp.cpp Table_OpenSans_Semibold_18_4bpp.cpp Table_OpenSans_Semibold_20_4bpp.cpp Table_OpenSans_Semibold_23_4bpp.cpp Table_OpenSans_Semibold_26_4bpp.cpp Table_OpenSans_SemiboldItalic_13_4bpp.cpp Table_SairaCondensed_Medium_14_4bpp.cpp Table_SairaCondensed_Medium_16_4bpp.cpp Table_SairaCondensed_Medium_20_4bpp.cpp Table_SairaCondensed_Medium_22_4bpp.cpp Table_SairaCondensed_Medium_28_4bpp.cpp Table_SairaCondensed_SemiBold_12_4bpp.cpp Table_SairaCondensed_SemiBold_14_4bpp.cpp Table_SairaCondensed_SemiBold_16_4bpp.cpp Table_SairaCondensed_SemiBold_20_4bpp.cpp Table_SairaSemiCondensed_Medium_34_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/aboutscreen_screen
    ../Gui/generated/gui_generated/src/aboutscreen_screen/: AboutScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/bathroomscreen_screen
    ../Gui/generated/gui_generated/src/bathroomscreen_screen/: BathroomScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/bathtubscreen_screen
    ../Gui/generated/gui_generated/src/bathtubscreen_screen/: BathtubScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../Gui/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../Gui/generated/gui_generated/src/containers/: AboutWheelElementBase.cpp BathtubWheelElementBase.cpp BathtubWheelElementCenterBase.cpp DeviceInfoBase.cpp DeviceInfoWheelElementsBase.cpp FanKnobBase.cpp FpsMcuLoadBase.cpp HomeUISplashContainerBase.cpp HomeUIWheelElementBase.cpp HomeUIWheelLargeElementsBase.cpp HomeUIWheelSmallElementsBase.cpp OvenSplashScreenBase.cpp OvenTemperatureContainerBase.cpp OvenTimerContainerBase.cpp OvenTimerWheelCenterElementBase.cpp OvenTimerWheelElementBase.cpp OvenWheelElementBase.cpp RecipeListElementBase.cpp RoomInfoBase.cpp RoomInfoWheelElementsBase.cpp WasherContainerBase.cpp WasherInstructionContainerBase.cpp WasherWheelCenterItemBase.cpp WasherWheelItemBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/extractorhoodscreen_screen
    ../Gui/generated/gui_generated/src/extractorhoodscreen_screen/: ExtractorHoodScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/hallwayscreen_screen
    ../Gui/generated/gui_generated/src/hallwayscreen_screen/: HallwayScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/homecontrolscreen_screen
    ../Gui/generated/gui_generated/src/homecontrolscreen_screen/: HomeControlScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/kitchenscreen_screen
    ../Gui/generated/gui_generated/src/kitchenscreen_screen/: KitchenScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/ovenscreen_screen
    ../Gui/generated/gui_generated/src/ovenscreen_screen/: OvenScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/recipescreen_screen
    ../Gui/generated/gui_generated/src/recipescreen_screen/: RecipeScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/recipeselectedscreen_screen
    ../Gui/generated/gui_generated/src/recipeselectedscreen_screen/: RecipeSelectedScreenViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/washerscreen_screen
    ../Gui/generated/gui_generated/src/washerscreen_screen/: WasherScreenViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../Gui/generated/images/src/: BitmapDatabase.cpp
  group Application/User/TouchGFX/generated/images/About
    ../Gui/generated/images/src/About/: aboutslider.cpp arrowDown.cpp bgTop.cpp infoBackButton.cpp infoMjolnerLogo.cpp infoSTLogo.cpp laptop.cpp laptopMjolner.cpp laptopRocket.cpp play_about_video_icon.cpp videobg.cpp
  group Application/User/TouchGFX/generated/images/BathRoom
    ../Gui/generated/images/src/BathRoom/: bathroom_bg.cpp bathtub_display_on.cpp bathtub_glow.cpp bathtub_water_on.cpp go_back_button.cpp homecontrol_display_on.cpp homecontrol_glow.cpp washing_machine_display_on.cpp washing_machine_glow.cpp washing_machine_on.cpp
  group Application/User/TouchGFX/generated/images/Bathtub
    ../Gui/generated/images/src/Bathtub/: BathTub_overlay.cpp BathTub_UI_bg.cpp bathtub_water.cpp colorwheel_250x250px.cpp colorwheel_picker_40x40px.cpp jets_off_img.cpp jets_on_img.cpp light_off.cpp light_on.cpp power_icon.cpp temp_off.cpp temp_on.cpp top_go_back.cpp wheel_select_top.cpp
  group Application/User/TouchGFX/generated/images/Bathtub/Jets_Control
    ../Gui/generated/images/src/Bathtub/Jets_Control/: jets_bg.cpp jets_off.cpp jets_on.cpp
  group Application/User/TouchGFX/generated/images/Bathtub/Light_Color
    ../Gui/generated/images/src/Bathtub/Light_Color/: lightColor_bg.cpp lightColor_selector_dot.cpp lightOff.cpp lightOn.cpp
  group Application/User/TouchGFX/generated/images/Bathtub/Temperature_wheel
    ../Gui/generated/images/src/Bathtub/Temperature_wheel/: C_F_off.cpp C_on.cpp F_on.cpp gradient_center.cpp gradient_overlay.cpp temperature_bg.cpp
  group Application/User/TouchGFX/generated/images/ExtractorHood
    ../Gui/generated/images/src/ExtractorHood/: air_on.cpp AirControl_bg.cpp AirControl_off.cpp AirControl_on.cpp ExtractorHoodButtonOverlay.cpp Fan_bg.cpp fan_button_off.cpp fan_button_on.cpp gitter.cpp hood_lights_on.cpp light_button_off.cpp light_button_on.cpp Propel.cpp slider.cpp slider_on.cpp sliderBg.cpp Spped_knob.cpp
  group Application/User/TouchGFX/generated/images/ExtractorHood/fanImages
    ../Gui/generated/images/src/ExtractorHood/fanImages/: Frames_00000.cpp Frames_00001.cpp Frames_00002.cpp Frames_00003.cpp Frames_00004.cpp Frames_00005.cpp Frames_00006.cpp Frames_00007.cpp Frames_00008.cpp Frames_00009.cpp
  group Application/User/TouchGFX/generated/images/Hallway
    ../Gui/generated/images/src/Hallway/: bathroom_normal.cpp bathroom_pressed.cpp infoButton.cpp kitchen_normal.cpp kitchen_pressed.cpp sky_bg.cpp sky_bg_reverse.cpp ST_HouseDemo_UI_bg.cpp ST_HouseDemo_UI_intro.cpp window_bg.cpp
  group Application/User/TouchGFX/generated/images/HomeControl_UI/Device_boxes
    ../Gui/generated/images/src/HomeControl_UI/Device_boxes/: bathtub.cpp bathtub_small.cpp extractor_hood_big.cpp food_recipies.cpp home_temp_big.cpp oven_big.cpp room_temp_big.cpp top_gradient_overlay.cpp washing_machine_big.cpp
  group Application/User/TouchGFX/generated/images/HomeControl_UI/MainScreen
    ../Gui/generated/images/src/HomeControl_UI/MainScreen/: arrow_left.cpp arrow_left_pressed.cpp arrow_right.cpp arrow_right_pressed.cpp devices_normal.cpp devices_selected.cpp go_back_button_bath.cpp go_back_button_home_control.cpp go_back_button_pressed.cpp info_air_humidity.cpp main_bg_home_control.cpp main_go_back_button.cpp main_slider_device.cpp main_slider_device_small.cpp main_slider_off.cpp main_slider_off_small.cpp main_slider_temp.cpp main_slider_temp_small.cpp music.cpp pesonalize.cpp recipes.cpp schedule_icon.cpp Select_Glow.cpp selectedTempBG.cpp settings_icon.cpp temperature_normal.cpp temperature_selected.cpp
  group Application/User/TouchGFX/generated/images/HomeControl_UI/Splash_UI
    ../Gui/generated/images/src/HomeControl_UI/Splash_UI/: HomeControl_UI_bg.cpp
  group Application/User/TouchGFX/generated/images/Kitchen
    ../Gui/generated/images/src/Kitchen/: Air_select.cpp Cookpot_on.cpp cooktop_select.cpp fan_display_on.cpp homeBtn.cpp Kitchen_UI_bg.cpp Lights_on.cpp oven_display_on.cpp Oven_on.cpp oven_select.cpp recipies_display_on.cpp termo_select.cpp
  group Application/User/TouchGFX/generated/images/Oven_UI
    ../Gui/generated/images/src/Oven_UI/: bottomBar.cpp btn_bg.cpp go_back_kitchen.cpp main_bg.cpp power_button.cpp power_button_off.cpp
  group Application/User/TouchGFX/generated/images/Oven_UI/Main_oven_select
    ../Gui/generated/images/src/Oven_UI/Main_oven_select/: buttonOverlay.cpp icon_buttom.cpp icon_buttom_active.cpp icon_clean.cpp icon_clean_active.cpp icon_grill.cpp icon_grill_active.cpp icon_hotair.cpp icon_hotair_active.cpp icon_hotair_grill.cpp icon_hotair_grill_active.cpp icon_light.cpp icon_light_active.cpp icon_top.cpp icon_top_active.cpp main_bundbar_bg.cpp Start_knap.cpp Start_knap_pressed.cpp Stop_knap.cpp Stop_knap_pressed.cpp tempOverlay.cpp
  group Application/User/TouchGFX/generated/images/Oven_UI/Power
    ../Gui/generated/images/src/Oven_UI/Power/: Oven_power_bg_clean.cpp power_button_big.cpp power_button_pressed_big.cpp
  group Application/User/TouchGFX/generated/images/Oven_UI/Set_temperature
    ../Gui/generated/images/src/Oven_UI/Set_temperature/: ok_button_pressed.cpp rotate_wheel_bottom.cpp temp_wheel_01.cpp temp_wheel_02.cpp temp_wheel_03.cpp temp_wheel_04.cpp temp_wheel_05.cpp temp_wheel_06.cpp temp_wheel_07.cpp temp_wheel_08.cpp
  group Application/User/TouchGFX/generated/images/Oven_UI/Set_Timer
    ../Gui/generated/images/src/Oven_UI/Set_Timer/: Background_bg.cpp gradient_timer_overlay.cpp Main_timer_select.cpp ok_button.cpp
  group Application/User/TouchGFX/generated/images/Recipes
    ../Gui/generated/images/src/Recipes/: back_top_ui.cpp difficulty_icon.cpp go_back.cpp main_ui_bg.cpp Pasta_01.cpp Pasta_02.cpp Pasta_03.cpp Pasta_04.cpp Pasta_05.cpp Pasta_06.cpp Pasta_07.cpp paste_big_bg.cpp plates_icon.cpp play_video_icon.cpp Scroll_gradient_overlay.cpp time_icon.cpp top_text.cpp top_ui_bg.cpp
  group Application/User/TouchGFX/generated/images/Washer
    ../Gui/generated/images/src/Washer/: allergy.cpp back_center_gray.cpp back_center_white.cpp background.cpp blue_done.cpp blue_start.cpp bottom_bar.cpp eco_wash.cpp heat_60.cpp icon_allergy_50px.cpp icon_center_activewear.cpp icon_center_activewear_medium.cpp icon_center_delicates.cpp icon_center_delicates_medium.cpp icon_center_ecowash.cpp icon_center_ecowash_medium.cpp icon_center_heavyduty.cpp icon_center_heavyduty_medium.cpp icon_center_normal.cpp icon_center_normal_medium.cpp icon_center_quickwash.cpp icon_center_quickwash_medium.cpp icon_center_smartwash.cpp icon_center_smartwash_medium.cpp icon_eco_wash_50px.cpp icon_heat_20_50px.cpp icon_heat_30_50px.cpp icon_heat_40_50px.cpp icon_heat_60_50px.cpp icon_heat_90_50px.cpp icon_instructions_40px.cpp icon_prewash_50px.cpp icon_soil_high_50px.cpp icon_soil_light_50px.cpp icon_soil_medium_50px.cpp icon_spin_speed_1000_rpm_50px.cpp icon_spin_speed_1200_rpm_50px.cpp icon_spin_speed_1400_rpm_50px.cpp icon_spin_speed_1600_rpm_50px.cpp icon_spin_speed_600_rpm_50px.cpp icon_spin_speed_800_rpm_50px.cpp left_arrow.cpp pause_stop_button.cpp prewash.cpp right_arrow.cpp running_button.cpp side_gradient_left.cpp side_gradient_right.cpp soil_level_medium.cpp spin_1600.cpp top_bar.cpp top_wash_prewash_active.cpp top_wash_prewash_done.cpp top_wash_prewash_inactive.cpp top_wash_rinsing_active.cpp top_wash_rinsing_done.cpp top_wash_rinsing_inactive.cpp top_wash_spin_cycle_active.cpp top_wash_spin_cycle_done.cpp top_wash_spin_cycle_inactive.cpp top_wash_washing_active.cpp top_wash_washing_done.cpp top_wash_washing_inactive.cpp Washer_demo_icon.cpp
  group Application/User/TouchGFX/generated/images/Washer/center_frames_cropped
    ../Gui/generated/images/src/Washer/center_frames_cropped/: Comp_00000.cpp Comp_00001.cpp Comp_00002.cpp Comp_00003.cpp Comp_00004.cpp Comp_00005.cpp Comp_00006.cpp Comp_00007.cpp Comp_00008.cpp Comp_00009.cpp Comp_00010.cpp Comp_00011.cpp Comp_00012.cpp Comp_00013.cpp Comp_00014.cpp Comp_00015.cpp Comp_00016.cpp Comp_00017.cpp Comp_00018.cpp Comp_00019.cpp Comp_00020.cpp Comp_00021.cpp Comp_00022.cpp Comp_00023.cpp Comp_00024.cpp Comp_00025.cpp Comp_00026.cpp
  group Application/User/TouchGFX/generated/images/Washer/video
    ../Gui/generated/images/src/Washer/video/: back_arrow.cpp video_background.cpp video_pause_button.cpp video_play_button.cpp
  group Application/User/TouchGFX/generated/images/Washer/wash_frames
    ../Gui/generated/images/src/Washer/wash_frames/: wash_frame_01.cpp wash_frame_02.cpp wash_frame_03.cpp wash_frame_04.cpp wash_frame_05.cpp wash_frame_06.cpp wash_frame_07.cpp wash_frame_08.cpp wash_frame_09.cpp wash_frame_10.cpp wash_frame_11.cpp
  group Application/User/TouchGFX/generated/texts
    ../Gui/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/aboutscreen_screen
    ../Gui/gui/src/aboutscreen_screen/: AboutScreenPresenter.cpp AboutScreenView.cpp
  group Application/User/TouchGFX/gui/bathroomscreen_screen
    ../Gui/gui/src/bathroomscreen_screen/: BathroomScreenPresenter.cpp BathroomScreenView.cpp
  group Application/User/TouchGFX/gui/bathtubscreen_screen
    ../Gui/gui/src/bathtubscreen_screen/: BathtubScreenPresenter.cpp BathtubScreenView.cpp
  group Application/User/TouchGFX/gui/common
    ../Gui/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../Gui/gui/src/containers/: AboutWheelElement.cpp BathtubWheelElement.cpp BathtubWheelElementCenter.cpp DeviceInfo.cpp DeviceInfoWheelElements.cpp FanKnob.cpp FpsMcuLoad.cpp HomeUISplashContainer.cpp HomeUIWheelElement.cpp HomeUIWheelLargeElements.cpp HomeUIWheelSmallElements.cpp OvenSplashScreen.cpp OvenTemperatureContainer.cpp OvenTimerContainer.cpp OvenTimerWheelCenterElement.cpp OvenTimerWheelElement.cpp OvenWheelElement.cpp RecipeListElement.cpp RoomInfo.cpp RoomInfoWheelElements.cpp WasherContainer.cpp WasherInstructionContainer.cpp WasherWheelCenterItem.cpp WasherWheelItem.cpp
  group Application/User/TouchGFX/gui/extractorhoodscreen_screen
    ../Gui/gui/src/extractorhoodscreen_screen/: AnimatedImage2.cpp ExtractorHoodScreenPresenter.cpp ExtractorHoodScreenView.cpp
  group Application/User/TouchGFX/gui/hallwayscreen_screen
    ../Gui/gui/src/hallwayscreen_screen/: hallwayScreenPresenter.cpp hallwayScreenView.cpp
  group Application/User/TouchGFX/gui/homecontrolscreen_screen
    ../Gui/gui/src/homecontrolscreen_screen/: HomeControlScreenPresenter.cpp HomeControlScreenView.cpp
  group Application/User/TouchGFX/gui/kitchenscreen_screen
    ../Gui/gui/src/kitchenscreen_screen/: KitchenScreenPresenter.cpp KitchenScreenView.cpp
  group Application/User/TouchGFX/gui/model
    ../Gui/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/ovenscreen_screen
    ../Gui/gui/src/ovenscreen_screen/: OvenScreenPresenter.cpp OvenScreenView.cpp
  group Application/User/TouchGFX/gui/recipescreen_screen
    ../Gui/gui/src/recipescreen_screen/: RecipeScreenPresenter.cpp RecipeScreenView.cpp
  group Application/User/TouchGFX/gui/recipeselectedscreen_screen
    ../Gui/gui/src/recipeselectedscreen_screen/: RecipeSelectedScreenPresenter.cpp RecipeSelectedScreenView.cpp
  group Application/User/TouchGFX/gui/washerscreen_screen
    ../Gui/gui/src/washerscreen_screen/: WasherScreenPresenter.cpp WasherScreenView.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../Drivers/BSP/STM32H750B-DK/: stm32h750b_discovery.c stm32h750b_discovery_bus.c stm32h750b_discovery_qspi.c stm32h750b_discovery_sdram.c stm32h750b_discovery_ts.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_msp_template.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Core/Src/: usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/libJPEG
    ../../../../../Middlewares/Third_Party/LibJPEG/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middlewares/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Middlewares/TouchGFX/Target
    ../Gui/target/: BoardConfiguration.cpp GPIO.cpp STM32H750TouchController.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp
  group Middlewares/TouchGFX/Widgets
    ../Gui/widgets/src/: JPEGFile.cpp MJPEGReader.cpp MJPEGWidget.cpp
